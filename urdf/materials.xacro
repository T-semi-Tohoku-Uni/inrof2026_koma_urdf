Commit message: feat(launch): fixed

File: urdf/materials.xacro (robot description, xacro)
@@ -22,3 +22,6 @@
   <color rgba="0.7019607843137254 0.7019607843137254 0.7019607843137254 1.0"/>
 </material>
+<material name="oak">
+  <color rgba="0.700 0.700 0.700 1.000"/>
+</material>
 </robot>
